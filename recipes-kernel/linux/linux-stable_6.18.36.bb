require linux-stable.inc

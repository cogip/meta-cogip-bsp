FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}_${LINUX_VERSION}/:"

require linux-stable.inc

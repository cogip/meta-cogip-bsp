FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}_${PV}/:"

require linux-stable.inc
